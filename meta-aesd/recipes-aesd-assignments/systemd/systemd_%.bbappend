PACKAGECONFIG:append = "networkd resolved"

